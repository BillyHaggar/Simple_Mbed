# Keil uVision project Task411.uvprojx, settings and files
target Task411 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: Task411
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=2
  c define: DEVICE_RTC=1 TARGET_NUCLEO_F401RE TARGET_NAME=NUCLEO_F401RE ARM_MATH_CM4 COMPONENT_NSPE=1 TARGET_STM32F401RE TARGET_STM32F4 __ASSERT_MSG DEVICE_SLEEP=1 DEVICE_PORTINOUT=1 MBED_BUILD_TIMESTAMP=1558818223.34 TARGET_FF_MORPHO DEVICE_I2C_ASYNCH=1 TARGET_FF_ARDUINO TARGET_RTOS_M4_M7 DEVICE_SPISLAVE=1 DEVICE_PORTOUT=1 DEVICE_FLASH=1 DEVICE_STDIO_MESSAGES=1 TARGET_RELEASE TARGET_LIKE_MBED DEVICE_SERIAL_FC=1 DEVICE_SERIAL=1 DEVICE_ANALOGIN=1 TARGET_LIKE_CORTEX_M4 TARGET_CORTEX_M MBED_ROM_SIZE=0x80000 USB_STM_HAL MBED_ROM_START=0x8000000 DEVICE_USTICKER=1 DEVICE_I2C=1 __CORTEX_M4 MBED_RAM_START=0x20000000 TARGET_CORTEX COMPONENT_PSA_SRV_IMPL=1 COMPONENT_PSA_SRV_EMUL=1 TOOLCHAIN_ARM DEVICE_INTERRUPTIN=1 TOOLCHAIN_ARM_STD __CMSIS_RTOS DEVICE_PWMOUT=1 DEVICE_SERIAL_ASYNCH=1 DEVICE_MPU=1 TARGET_STM TARGET_FAMILY_STM32 DEVICE_SPI=1 __MBED__=1 MBED_RAM_SIZE=0x18000 TARGET_STM32F401xE DEVICE_LPTICKER=1 DEVICE_PORTIN=1 TARGET_M4 __FPU_PRESENT=1 DEVICE_I2CSLAVE=1 USBHOST_OTHER DEVICE_SPI_ASYNCH=1 TRANSACTION_QUEUE_SIZE_SPI=2 __MBED_CMSIS_RTOS_CM
  c misc: --no_rtti --split_sections -c --cpu=Cortex-M4.fp --apcs=interwork --no_depend_system_headers --md --gnu --preinclude=mbed_config.h
  c include: /usr/src/mbed-sdk;mbed;mbed/TARGET_NUCLEO_F401RE;mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4;mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M4,-DUSB_STM_HAL,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-DUSBHOST_OTHER,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: .\mbed\TARGET_NUCLEO_F401RE\TOOLCHAIN_ARM_STD\stm32f401xe.sct
  link misc: --predefine="-DMBED_RAM_SIZE=0x18000" --predefine="-DMBED_ROM_START=0x8000000" --predefine="-DMBED_RAM_START=0x20000000" --predefine="-DMBED_BOOT_STACK_SIZE=4096" --show_full_path --predefine="-DMBED_ROM_SIZE=0x80000" --keep=os_cb_sections
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
    mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o hal_tick.o mbed.ar mbed_overrides.o retarget.o startup_stm32f401xe.o stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_can.o stm32f4xx_hal_cec.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_cryp.o stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_eth.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_flash_ramfunc.o stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.o stm32f4xx_hal_ltdc.o stm32f4xx_hal_msp_template.o stm32f4xx_hal_nand.o stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.o stm32f4xx_hal_smartcard.o stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.o stm32f4xx_hal_sram.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.o stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.o stm32f4xx_ll_sdmmc.o stm32f4xx_ll_usb.o sys.o system_stm32f4xx.o
    mbed/TARGET_NUCLEO_F401RE/: cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h hal_tick.h stm32_hal_legacy.h stm32f401xe.h stm32f4xx.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h system_stm32f4xx.h
    mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE/: device.h objects.h PeripheralNames.h PinNames.h PortNames.h
    mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/: gpio_object.h PeripheralPins.h
  group Task411
    ./: main.cpp mbed_config.h
software components: CMSIS:CORE 5.2.0
